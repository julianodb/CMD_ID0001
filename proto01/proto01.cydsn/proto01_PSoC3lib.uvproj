# Keil uVision project proto01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866LTI-030 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: proto01_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h VREF.c VREF.h VREF_aliases.h SENSOROUTPUT.c SENSOROUTPUT.h SENSOROUTPUT_aliases.h PGA_1.c PGA_1.h PGA_1_PM.c ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c Filter_1.c Filter_1.h Filter_1_PM.c Filter_1_PVT.c Filter_1_PVT.h Filter_1_RAM_Data.c Filter_1_Coefficients.c VDAC8_1.c VDAC8_1.h VDAC8_1_PM.c LED1.c LED1.h LED1_aliases.h GND.c GND.h GND_aliases.h VDAC8_2.c VDAC8_2.h VDAC8_2_PM.c LED2.c LED2.h LED2_aliases.h isr_1.c isr_1.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_IRQ.c ADC_DelSig_1_IRQ.h ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h
target Release (MCS-51)
  device: CY8C3866LTI-030 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: proto01_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
